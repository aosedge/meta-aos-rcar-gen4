COMPATIBLE_HOST= "aarch64.*-linux"

PACKAGE_INSTALL = " \
    initramfs-module-nfsrootfs \
    initramfs-module-rundir \
    initramfs-module-udev \
    initramfs-module-lvm \
    initramfs-module-opendisk \
    initramfs-module-aosupdate \
    kernel-module-loop \
    kernel-module-overlay \
    kernel-module-squashfs \
    busybox \
    optee-os \
    optee-client \
    lvm2 \
"
