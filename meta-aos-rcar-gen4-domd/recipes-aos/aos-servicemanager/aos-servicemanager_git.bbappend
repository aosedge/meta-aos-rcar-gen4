FILESEXTRAPATHS:prepend:aos-main-node := "${THISDIR}/files/main-node:"
